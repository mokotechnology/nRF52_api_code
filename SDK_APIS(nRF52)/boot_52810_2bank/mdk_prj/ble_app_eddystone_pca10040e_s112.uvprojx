# Keil uVision project ble_app_eddystone_pca10040e_s112.uvprojx, settings and files
target nrf52810_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.42.0
  cpu: IROM(0x00000000,0x30000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(64000000) ELITTLE
  output: ibeacon_boot +hex
  AfterMake: .\hex2bin .\_build\ibeacon_boot.hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52832 FLOAT_ABI_SOFT NRF52810_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S112 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_escs;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\balloc;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\ecc;..\components\libraries\eddystone;..\components\libraries\experimental_log;..\components\libraries\experimental_log\src;..\components\libraries\experimental_memobj;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\strerror;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\twi_mngr;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common;..\components\softdevice\s112\headers;..\components\softdevice\s112\headers\nrf52;..\components\toolchain;.\occ\occ\OberonHAPCrypto;.\occ\occ\OberonHAPCryptoP256;.\occ\occ\OberonHAPCryptoP256\include;.\occ\occ\OberonHAPCrypto\include;..\external\cifra_AES128-EAX;..\external\tiny-AES128;..\src;..\mdk_prj;..\src\segger_rtt;..\module\boot;..\module\dfu;..\module\wdt;..\module\ble_fifo;..\components\libraries\bootloader;..\components\libraries\bootloader\dfu
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52832,-DFLOAT_ABI_SOFT,-DNRF52810_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS112,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_escs;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\balloc;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\ecc;..\components\libraries\eddystone;..\components\libraries\experimental_log;..\components\libraries\experimental_log\src;..\components\libraries\experimental_memobj;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\strerror;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\twi_mngr;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common;..\components\softdevice\s112\headers;..\components\softdevice\s112\headers\nrf52;..\components\toolchain;.\occ\occ\OberonHAPCrypto;.\occ\occ\OberonHAPCryptoP256;.\occ\occ\OberonHAPCryptoP256\include;.\occ\occ\OberonHAPCrypto\include;..\external\cifra_AES128-EAX;..\external\tiny-AES128
  library: MicroLIB
  memory RVCT4: ROM 0x2f000 size 0x1000
  memory RVCT9: RAM 0x20004708 size 0x1540
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ../components/libraries/bootloader/: nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c
    ../src/: boot.c
    ../components/libraries/bootloader/dfu/: nrf_dfu_mbr.c
target flash_s112_nrf52810_5.1.0_softdevice (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.42.0
  cpu: as above
  output: s112_nrf52810_5.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20001cd0 size 0x4330
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
